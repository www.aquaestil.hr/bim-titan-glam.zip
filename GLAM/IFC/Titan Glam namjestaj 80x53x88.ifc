Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-07-20T13:21:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 20 13:21:15 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{D19EEEF7-BB54-4069-9CAB-32531FF7B7F2}\ifc * Database version: 5507 * Database creation date: Tue Jul 20 13:21:14 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 20 13:21:15 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 20 13:21:15 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: 80x53x88, Titan Glam namjestaj_R18:80x53x88:378500
In: Level 1
Material: AQ_Crna MDF, AQ_Crna plastificirani čelik, AQ_Astone_white(1)
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil
Pset_DistributionFlowElementCommon - Reference: Titan Glam namjestaj_R18:80x53x88
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 2.24803 m2; Volume: 0.0316837 m3
Identity Data - Mark: 18
Mechanical - System Classification: Sanitary
Other - Category: Plumbing Fixtures; Family: Titan Glam namjestaj_R18: 80x53x88; Family and Type: Titan Glam namjestaj_R18: 80x53x88; Type: Titan Glam namjestaj_R18: 80x53x88; Type Id: Titan Glam namjestaj_R18: 80x53x88
Phasing - Phase Created: New Construction
Dimensions(Type) - Sirina: 800 mm; Sirina umivaonika: 803 mm
Identity Data(Type) - Boja: crna; Izradio: Intelika d.o.o.; Manufacturer: Aquaestil; Materijal: Astone, plastificirani čelik, MDF; Model: TITAN GLAM; Mogućnost ugradnje: uz zid; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Sifon: Ø46; Type Name: 80x53x88; Web adresa: https://www.aquaestil.hr/hr/proizvodi/titan-premium-linija/kupaonski-namjestaj-titan/25-.html
Materials and Finishes(Type) - Materijal fronte vrata i ladica: AQ_Crna MDF; Materijal konstrukcije: AQ_Crna plastificirani čelik; Materijal umivaonika: AQ_Astone_white(1)
Other(Type) - Category: Plumbing Fixtures; Family Name: Titan Glam namjestaj_R18
